options:
  parameters:
    author: tao
    generate_options: qt_gui
    id: RF_location
    output_language: python
    title: RF_location
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    Num_Samples_To_Count: '32000'
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Num_Samples_To_Count=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Select Control',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Num_Samples_To_Count = Num_Samples_To_Count
              self.portName = 'messageOutput'
              self.message_port_register_out(pmt.intern(self.portName))
              self.state = 0
              self.counter = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.counter = self.counter + len(output_items[0])
              
              if (self.counter > self.Num_Samples_To_Count):
                  PMT_msg = pmt.from_long(self.state)
                  self.message_port_pub(pmt.intern(self.portName), PMT_msg)
                  self.state = (self.state + 1) % 5
                  self.counter = 0
                  
              output_items[0][:]=input_items[0]
              return len(output_items[0])
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Set_sink_center_freq',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName= 'get_message'
              self.outPortName= 'sink_message'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.message_port_register_out(pmt.intern(self.outPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.selector = 0
              self.freqency_list = [400e6, 420e6, 440e6, 460e6, 480e6]
              self.now = 0
          
          def handle_msg(self, msg):
              self.selector = pmt.to_long(msg)
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.now = self.frequency_list[self.selector]
              # set the center frequency of sink
              # 创建一个PMT字典
              command = pmt.make_dict()
              command = pmt.dict_add(command, pmt.intern("freq"), pmt.from_double(self.now))
              command = pmt.dict_add(command, pmt.intern("chan"), pmt.from_long(1))

              # 发送命令消息到输出端口
              self.message_port_pub(pmt.intern(self.outPortName), command)

              return len(output_items[0])
  states: {}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Set_source_center_freq',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName= 'get_message'
              self.outPortName= 'source_message'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.message_port_register_out(pmt.intern(self.outPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.selector = 0
              self.freqency_list=[400e6, 420e6, 440e6, 460e6, 480e6]
              self.now_freq = 0
              self.now_gain = 0
              
          def handle_msg(self, msg):
              self.selector = pmt.to_long(msg)
          
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              self.now = 2 * self.freqency_list[self.selector]
              # set the center frequency of source
              # 创建一个PMT字典
              command = pmt.make_dict()
              command = pmt.dict_add(command, pmt.intern("freq"), pmt.from_double(self.now_freq))
              command = pmt.dict_add(command, pmt.intern("chan"), pmt.from_long(1))
              command = pmt.dict_add(command, pmt.intern("gain"), pmt.from_double(self.now_gain))

              # 发送命令消息到输出端口
              self.message_port_pub(pmt.intern(self.outPortName), command)
                   
              return len(output_items[0])
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    dev_addr: 192.168.10.2
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    dev_addr: 192.168.10.2
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_4, '0']
- [epy_block_4, '0', qtgui_time_sink_x_0, '0']
- [epy_block_4, messageOutput, blocks_message_debug_0, print]
- [epy_block_4, messageOutput, epy_block_5, get_message]
- [epy_block_4, messageOutput, epy_block_6, get_message]
- [epy_block_5, sink_message, uhd_usrp_sink_1, command]
- [epy_block_6, source_message, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_1, '0']

metadata:
  file_format: 1
