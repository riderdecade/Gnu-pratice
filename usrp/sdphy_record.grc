options:
  parameters:
    author: iiot434
    generate_options: qt_gui
    id: sdphy_record
    output_language: python
    title: sdphy_record
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: fc_rx
  id: variable
  parameters:
    value: 911e6
  states: {}
- name: fc_tx
  id: variable
  parameters:
    value: 910.0e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '30'
    step: '1'
    stop: '80'
    value: '60'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: label_0
  id: variable_qtgui_label
  parameters:
    label: Protocol
    type: string
    value: protocol
  states: {}
- name: label_1
  id: variable_qtgui_label
  parameters:
    label: frequency_exciation
    type: real
    value: fc_tx
  states: {}
- name: label_1_0
  id: variable_qtgui_label
  parameters:
    label: frequency_backscatter
    type: real
    value: fc_rx
  states: {}
- name: label_1_2
  id: variable_qtgui_label
  parameters:
    label: sampling rate
    type: real
    value: samp_rate
  states: {}
- name: protocol
  id: variable
  parameters:
    value: '"DCSS Backscatter"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 50e3
  states: {state: disabled}
- name: sf
  id: variable
  parameters:
    value: '8'
  states: {}
- name: update_rate
  id: variable
  parameters:
    value: '0.000002'
  states: {}
- name: window
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/iiot434/lwh434/gr-dcss/v3/data
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/iiot434/lwh434/gr-dcss/v3/wave_dcss_64_pure_1Mfs_3Msr_0920
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: window
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: window
    type: complex
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport math\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, window=4096, bw=250e3, sf=8, samp_rate=250e3):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='dcss_demod_v6',   # will show up in GRC\n            in_sig=[(np.complex64, window)],\n            out_sig=[(np.complex64, window)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \"\"\" radio parameter \"\"\"\n        self.window = window\n        self.ind = 0\n        self.bw = bw\n        self.sf = sf\n        self.samp_rate = samp_rate\n        self.ber = 1\n        self.flag_demod = 0\n        self.n_symb = 64\n        self.tag_data = np.zeros(48)\n        \"\"\" buffer & sync \"\"\"\n        self.buffer_size = 5\n        self.buffer_data = np.zeros(4096*self.buffer_size,dtype=complex)  # data stream\n        self.buffer_xcorr = np.zeros(self.buffer_size) # xcorr max value\n        self.buffer_xcorr_overlap = np.zeros(self.buffer_size)  # xcorr max value overlap\n        self.raw_peaks = np.zeros(self.buffer_size)\n        self.raw_peaks_overlap = np.zeros(self.buffer_size)\n        self.pointer_data = 0\n        self.pointer_xcorr = 0\n        self.pointer_sync = -1\n        self.CORR_THRESH = 0.7\n        \"\"\" parameter preparison: generate chirp symbol \"\"\"\n        self.a1 = self.ind / pow(2, self.sf) * self.bw - self.bw / 2\n        self.a2 = self.bw**2 / 2**self.sf\n        self.n_t = round((math.pow(2, self.sf) / self.bw) / (1 / self.bw))\n        self.t = np.linspace(0, (math.pow(2, self.sf) - 1) / self.bw, self.n_t)\n        self.dchirp = math.e ** (1j * 2 * math.pi * (-0.5 * self.a2 * self.t ** 2 + self.bw / 2 * self.t + 0))\n        self.uchirp = math.e ** (1j * 2 * math.pi * (+0.5 * self.a2 * self.t ** 2 + self.bw / 2 * self.t + 0))\n        self.preamble = np.concatenate((self.dchirp, self.dchirp), axis=0)    \n        self.n_preamble = round(np.size(self.preamble,0))\n        self.n_ook = 16\n        self.n_offset = 0\n\n    def work(self, input_items, output_items):\n        \"\"\"working function: sdphy-sensor dcss demodulation version 5\"\"\"\n        \n        \"\"\" system initialization\"\"\"\n        self.pointer_sync = -1\n        self.flag_demod = 0\n        \n        \"\"\" buffer loading and correlation record \"\"\"\n        matfile = np.array(input_items[0])\n        matfile = matfile.transpose()     \n        n_sample = np.size(matfile, 0) # 4096\n        n_frame = np.size(matfile, 1)  # 1     \n        for i in range(n_frame):\n            data_in = matfile[:, i]\n            data_in = np.squeeze(data_in)\n            \"\"\" record last xcorr results \"\"\"\n            # # pointer_data now points to data_in last round\n            # # pointer_xcorr now points to the latest data_in\n            \n            tmp_data = self.buffer_data[int(self.pointer_data * 4096):int((self.pointer_data + 1) * 4096)]\n            tmp_xcorr = np.correlate(tmp_data, self.preamble, mode='valid')\n            # self.buffer_xcorr[int(self.pointer_data)] = np.max(abs(tmp_xcorr))\n            self.raw_peaks[int(self.pointer_data)] = np.argmax(abs(tmp_xcorr))\n            self.buffer_xcorr[int(self.pointer_data)] = abs(tmp_xcorr[int(self.raw_peaks[int(self.pointer_data)])])\n            \n            tmp_data_overlap = np.concatenate((self.buffer_data[int(self.pointer_data * 4096 + 2048):int((self.pointer_data+1) * 4096)], data_in[int(0):int(2048)]), axis=0)\n            tmp_xcorr_overlap = np.correlate(tmp_data_overlap, self.preamble, mode='valid')\n            # self.buffer_xcorr_overlap[int(self.pointer_data)] = np.max(abs(tmp_xcorr_overlap))\n            self.raw_peaks_overlap[int(self.pointer_data)] = np.argmax(abs(tmp_xcorr_overlap))\n            self.buffer_xcorr_overlap[int(self.pointer_data)] = abs(tmp_xcorr_overlap[int(self.raw_peaks_overlap[int(self.pointer_data)])])\n            \n            \"\"\" find possible peaks \"\"\"\n            threshold1 = self.CORR_THRESH * np.max(self.buffer_xcorr)\n            threshold2 = self.CORR_THRESH * np.max(self.buffer_xcorr_overlap)\n            if threshold1 > threshold2:\n                threshold = threshold1\n            else:\n                threshold = threshold2\n            \"\"\" # if it has not been sync, then keeps trying; else, skip \"\"\"\n            if self.pointer_sync != -1:\n                if self.pointer_data == self.buffer_size-1:  # idx from 0 to self.buffer_size-1\n                    self.pointer_data = 0\n                else:\n                    self.pointer_data = self.pointer_data + 1\n                if self.pointer_data == self.buffer_size-1:\n                    self.pointer_xcorr = 0\n                else:\n                    self.pointer_xcorr = self.pointer_data + 1\n                self.buffer_data[int(self.pointer_data * 4096):int((self.pointer_data + 1) * 4096)] = data_in  # buffer: (4096*self.buffer_size,)        \n                continue\n            else:\n                tmp_0 = self.buffer_xcorr[int(self.pointer_xcorr)]\n                tmp_1 = self.buffer_xcorr_overlap[int(self.pointer_xcorr)]\n                if tmp_0 > threshold and tmp_1 > threshold:  # xcorr = data + 1\n                    self.pointer_sync = self.pointer_xcorr\n                    if tmp_0 >= tmp_1:\n                        tmp_buffer = np.concatenate((self.buffer_data[int(self.pointer_sync * 4096):int(self.buffer_size * 4096)],\n                                                     self.buffer_data[int(0):int((self.pointer_sync) * 4096)]), axis=0)\n                        peaks_raw = self.raw_peaks[int(self.pointer_sync)]\n                    else:\n                        tmp_buffer = np.concatenate(\n                            (self.buffer_data[int(self.pointer_sync * 4096 + 2048):int(self.buffer_size * 4096)],\n                             self.buffer_data[int(0):int((self.pointer_sync) * 4096)]), axis=0)\n                        tmp_buffer = np.concatenate((tmp_buffer, data_in[0:2048]), axis=0)\n                        peaks_raw = self.raw_peaks_overlap[int(self.pointer_sync)]\n                elif tmp_0 > threshold and tmp_1 <= threshold:\n                    self.pointer_sync = self.pointer_xcorr\n                    tmp_buffer = np.concatenate((self.buffer_data[int(self.pointer_sync * 4096):int(self.buffer_size * 4096)],\n                                                 self.buffer_data[int(0):int((self.pointer_sync) * 4096)]), axis=0)\n                    peaks_raw = self.raw_peaks[int(self.pointer_sync)]\n                elif tmp_0 <= threshold and tmp_1 > threshold:\n                    self.pointer_sync = self.pointer_xcorr\n                    tmp_buffer = np.concatenate((self.buffer_data[int(self.pointer_sync * 4096 + 2048):int(self.buffer_size * 4096)],\n                                                 self.buffer_data[int(0):int((self.pointer_sync) * 4096)]), axis=0)\n                    tmp_buffer = np.concatenate((tmp_buffer, data_in[0:2048]), axis=0)\n                    peaks_raw = self.raw_peaks_overlap[int(self.pointer_sync)]\n                else:\n                    self.pointer_sync = -1\n            \"\"\" renew buffer_data, pointer_data and pointer_xcorr \"\"\"\n            if self.pointer_data == self.buffer_size-1:  # idx from 0 to 19\n                self.pointer_data = 0\n            else:\n                self.pointer_data = self.pointer_data + 1\n            if self.pointer_data == self.buffer_size-1:\n                self.pointer_xcorr = 0\n            else:\n                self.pointer_xcorr = self.pointer_data + 1\n            self.buffer_data[int(self.pointer_data * 4096):int((self.pointer_data + 1) * 4096)] = data_in  # buffer: (4096*20,)      \n         \n        \"\"\" set flag for demodulation \"\"\"\n        if self.pointer_sync != -1:\n            self.flag_demod = 1   \n            # print(np.shape(np.array(input_items)))\n        else:\n            self.flag_demod = 0     \n                   \n        \"\"\" run demodulation process \"\"\"\n        if self.flag_demod==1:\n            # print('find packets!')   \n            \"\"\" extract whole radio packet \"\"\"\n            n_sample_offset = self.n_preamble + self.n_ook + self.n_offset\n            n_sample_packet = round(np.size(self.dchirp,0) * self.n_symb)\n            sp = peaks_raw + n_sample_offset\n            ep = (sp + n_sample_packet - 1) + 1  \n            packet = tmp_buffer[int(sp):int(ep)]              \n            \"\"\" new version demodulation \"\"\"\n            len_chirp = np.size(self.dchirp, 0)\n            len_sequence = 16\n            sequence_bit = np.zeros(len_sequence)\n            sequence_strength = np.zeros(len_sequence)\n            threshold_coarse = np.average(abs(packet[0*len_chirp:len_sequence*len_chirp]))\n            for ii in range(len_sequence):  # 0,1,...,15\n                idx00 = ii * len_chirp\n                idx01 = (ii + 1) * len_chirp\n                tmp_symbol0 = packet[idx00:idx01]\n                sequence_strength[ii] = np.average(abs(tmp_symbol0))\n                if sequence_strength[ii] >= threshold_coarse:\n                    sequence_bit[ii] = 1\n                else:\n                    sequence_bit[ii] = 0\n            # if sequence_bit.tolist() == [1, 0, 1, 1, 0, 1, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0]:\n            if sequence_bit.tolist() == [0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0, 0]:\n            # if sequence_bit.tolist() == [1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 0]:\n                print(\"ID Correct\")\n                len_data = 48\n                data_bit = np.zeros(len_data)\n                threshold_fine = threshold_coarse\n                for ii in range(len_data):  # 0,1,...,47\n                    idx10 = (ii + len_sequence) * len_chirp\n                    idx11 = (ii + len_sequence + 1) * len_chirp\n                    tmp_symbol1 = packet[idx10:idx11]\n                    tmp_strength = np.average(abs(tmp_symbol1))\n                    if tmp_strength >= threshold_fine:\n                        data_bit[ii] = 1\n                    else:\n                        data_bit[ii] = 0\n                self.tag_data = data_bit\n                print(self.tag_data)\n            else:\n                print(\"ID Error\")\n                print(sequence_bit)\n                len_data = 48        \n        else:\n            # print('no peaks found!')\n            bits_rx = []\n                                        \n        \"\"\" return and datastream output \"\"\"\n        output_items[0][:] = input_items[0]\n        \n        return len(output_items[0])\n        \n        \n        \n        \n        \n"
    bw: bw
    samp_rate: samp_rate
    sf: sf
    window: window
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: fft_size
    type: complex
    update_time: update_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: fs
    center_freq0: fc_tx
    dev_args: '""'
    gain0: gain_tx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: fs
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc_rx
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain_rx
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_6, '0']
- [blocks_vector_to_stream_0, '0', blocks_null_sink_0, '0']
- [epy_block_6, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
