options:
  parameters:
    author: tao
    generate_options: qt_gui
    id: Fourth
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: probe_var
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100*0.000001
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 500*0.001
    freq: 2000*probe_var
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Waterfall
    num_tabs: '2'
  states: {}

connections:
- [analog_sig_source_x_0, '0', probe_signal, '0']
- [analog_sig_source_x_0_0, '0', audio_sink_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
