options:
  parameters:
    generate_options: qt_gui
    id: Second
    output_language: python
    title: Second
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2*1000
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1*1000
    step: '200'
    stop: 40*1000
    value: 10*1000
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 2*1000
    offset: '0'
    phase: '0'
    samp_rate: 10*1000
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 32*1000
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10*1000
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: 10*1000
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
