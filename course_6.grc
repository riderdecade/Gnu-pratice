options:
  parameters:
    author: tao
    generate_options: qt_gui
    id: course_6
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-samp_rate'
    step: '10'
    stop: samp_rate
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Multiply_Block_0
  id: Multiply_Block
  parameters:
    frequency: frequency
    samp_rate: samp_rate
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [Multiply_Block_0, '0', blocks_throttle_0, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', Multiply_Block_0, '0']

metadata:
  file_format: 1
