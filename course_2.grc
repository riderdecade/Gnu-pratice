options:
  parameters:
    author: tao
    generate_options: qt_gui
    id: course_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '4000'
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '-5000'
    step: '50'
    stop: '5000'
    value: '50'
  states: {state: disabled}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    comment: a chooser
    label: Frequency
    labels: '["frequency:0"," frequency:-3000", "frequency:-2000", "frequency:-1000"," frequency:1000"]'
    num_opts: '0'
    options: '[0, -3000, -2000, -1000, 1000]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
